# Keil uVision project freertos_hello.uvprojx, settings and files
target freertos_hello debug (6130001::V6.13.1::.\ARMCLANG)
  device: LPC54608J512ET180 NXP
  pack: NXP.LPC54608_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_hello.out +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: board;source;CMSIS;LPC54608/arm;amazon-freertos/freertos_kernel/include;amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F;component/lists;component/serial_manager;component/uart;device;doc;drivers;startup;utilities
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: libs\keil_lib_power.lib --remove
libs/keil_lib_power.lib
--remove
  group amazon-freertos/freertos_kernel
    amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos_kernel/include
    amazon-freertos/freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F
    amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos/freertos_kernel/portable/MemMang
    amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
  group amazon-freertos/freertos_kernel/portable
    amazon-freertos/freertos_kernel/portable/: readme.txt
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm4.h mpu_armv7.h mpu_armv8.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: uart.h usart_adapter.c
  group device
    device/: fsl_device_registers.h LPC54608.h LPC54608_features.h system_LPC54608.c system_LPC54608.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_emc.c fsl_emc.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
    D:/nxp/NXP/SDK_2.7.0_LPC54608J512/devices/LPC54608/drivers/: fsl_gint.c fsl_inputmux.c fsl_pint.c
  group source
    source/: freertos_hello.c FreeRTOSConfig.h
  group startup
    startup/: startup_LPC54608.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
target freertos_hello release (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: NXP.LPC54608_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: freertos_hello.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1, SERIAL_PORT_TYPE_UART=1, FSL_RTOS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL, NDEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
