# Keil uVision project dev_audio_generator_freertos.uvprojx, settings and files
target dev_audio_generator_freertos debug (6130001::V6.13.1::.\ARMCLANG)
  device: LPC54608J512ET180 NXP
  pack: NXP.LPC54608_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_audio_generator_freertos.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: _DEBUG=1, DEBUG, CPU_LPC54608, USB_STACK_FREERTOS, CPU_LPC54608J512ET180=1, USB_STACK_FREERTOS_HEAP_SIZE=16384, USB_STACK_USE_DEDICATED_RAM=1, FSL_RTOS_FREE_RTOS, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: board;source;CMSIS;LPC54608/arm;amazon-freertos/freertos_kernel/include;amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F;component/lists;component/osa;component/serial_manager;component/uart;device;doc;drivers;lpcxpresso54608/usb_examples/usb_device_audio_generator/freertos;startup;usb/device/class;usb/device/class/audio;usb/device/include;usb/device/source;usb/device/source/lpcip3511;usb/include;utilities
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: LPC54608J512_flash.scf
  link misc: libs\keil_lib_power.lib --remove --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x100" --predefine="-D__usb_use_usbram__=1"
libs/keil_lib_power.lib
--remove
  group amazon-freertos/freertos_kernel
    amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos_kernel/include
    amazon-freertos/freertos_kernel/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F
    amazon-freertos/freertos_kernel/portable/GCC/ARM_CM4F/: port.c portmacro.h
  group amazon-freertos/freertos_kernel/portable/MemMang
    amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
  group amazon-freertos/freertos_kernel/portable
    amazon-freertos/freertos_kernel/portable/: readme.txt
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm4.h mpu_armv7.h mpu_armv8.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/osa
    component/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: uart.h usart_adapter.c
  group device
    device/: fsl_device_registers.h LPC54608.h LPC54608_features.h system_LPC54608.c system_LPC54608.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dma.c fsl_dma.h fsl_dmic.c fsl_dmic.h fsl_dmic_dma.c fsl_dmic_dma.h fsl_emc.c fsl_emc.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_sctimer.c fsl_sctimer.h fsl_usart.c fsl_usart.h
  group lpcxpresso54608/usb_examples/usb_device_audio_generator/freertos
    lpcxpresso54608/usb_examples/usb_device_audio_generator/freertos/: readme.pdf
  group source
    source/: audio_data_dmic.c audio_data_dmic.h audio_generator.c audio_generator.h FreeRTOSConfig.h usb_audio_config.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
  group startup
    startup/: startup_LPC54608.s
  group usb
    usb/: ChangeLogKSDK.txt
  group usb/device/class/audio
    usb/device/class/audio/: usb_device_audio.c usb_device_audio.h
  group usb/device/class
    usb/device/class/: usb_device_class.c usb_device_class.h
  group usb/device/include
    usb/device/include/: usb_device.h
  group usb/device/source/lpcip3511
    usb/device/source/lpcip3511/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/device/source
    usb/device/source/: usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h
  group usb/include
    usb/include/: usb.h usb_misc.h usb_spec.h
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
target dev_audio_generator_freertos release (ARM-ADS)
  device: LPC54608J512ET180 NXP
  pack: NXP.LPC54608_DFP.12.1.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dev_audio_generator_freertos.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: _DEBUG=0, NDEBUG, CPU_LPC54608, USB_STACK_FREERTOS, CPU_LPC54608J512ET180=1, USB_STACK_FREERTOS_HEAP_SIZE=16384, USB_STACK_USE_DEDICATED_RAM=1, FSL_RTOS_FREE_RTOS, FSL_OSA_BM_TASK_ENABLE=0, FSL_OSA_BM_TIMER_CONFIG=0, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL, NDEBUG
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC54608J512_flash.scf
  link misc: as above
